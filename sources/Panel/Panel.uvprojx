# Keil uVision project Panel.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Panel +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,DEBUG,PANEL
  c misc: --cpp
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware;..\libs\common;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\src\libs;..\common;.\src\Hardware\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;.\tests
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\Panel.sct
  group HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_dma.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_dma2d.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group src
    ./src/: defines.h main.cpp Log.h Log.cpp Settings.h Settings.cpp
  group Calculate
    ./src/Calculate/: ValueFPGA.h ValueCountPulse.cpp ValueDuration.cpp ValueFrequency.cpp ValuePeriod.cpp ValueFPGA.cpp
  group Display
    ./src/Display/: Colors.h Colors.cpp Console.h Console.cpp Display.h Display.cpp Indicator.h Indicator.cpp Display_stm.cpp Primitives.h Primitives.cpp RedrawingZone.h RedrawingZone.cpp Symbols.h Symbols.cpp Text.h Text.cpp
  group Display/Font
    ./src/Display/Font/: Font.h Font.cpp FontBig.h FontBig.cpp FontMid.h FontMid.cpp fontGOSTAU16BOLD.inc fontGOSTAU16BOLD.xml fontGOSTB28B.inc fontGOSTB28B.xml
  group Hardware
    ./src/Hardware/: FPGA.h FPGA.cpp FreqMeter.h FreqMeter.cpp VCP.h VCP.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f437xx.s system_stm32f4xx.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_EEPROM.cpp HAL_FSMC.cpp HAL_IT.cpp HAL_TIM.cpp HAL_USBD.cpp stm32f4xx_hal_conf.h
  group Hardware/USBD
    ./src/Hardware/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_core.cpp usbd_desc.cpp usbd_desc.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Keyboard
    ./src/Keyboard/: Keyboard.cpp Keyboard.h
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuItemsDef.h Hint.cpp Hint.h
  group Menu/Pages
    ./src/Menu/Pages/: Pages.h PageIndication.h PageIndication.cpp PageService.cpp
  group Menu/Pages/Channels
    ./src/Menu/Pages/Channels/: Channels.h Channels.cpp ChannelA.cpp ChannelB.cpp ChannelC.cpp ChannelD.cpp
  group Menu/Pages/Modes
    ./src/Menu/Pages/Modes/: Modes.h Modes.cpp PagesModes.cpp PageModesA.cpp PageModesB.cpp PageModesC.cpp PageModesD.cpp
  group Menu/Pages/Other
    ./src/Menu/Pages/Other/: PageColors.cpp PageInfo.cpp PageStatistics.cpp PageTuneColors.cpp
  group SCPI
    ./src/SCPI/: SCPI.txt SCPI.h SCPI.cpp UtilsSCPI.cpp UtilsSCPI.h BufferSCPI.cpp BufferSCPI.h
  group SCPI/Process
    ./src/SCPI/Process/: DataSender.h DataSender.cpp DataSCPI.cpp HeadSCPI.cpp InputSCPI.cpp MeasureSCPI.cpp SetSCPI.cpp UpgradeSCPI.cpp
  group Utils
    ./src/Utils/: Buffer.h Buffer.cpp Math.h Math.cpp Stack.h Stack.cpp String.h String.cpp Values.h Values.cpp ValueSTRICT.h ValueSTRICT.cpp Debug.cpp Debug.h StringUtils.cpp StringUtils.h
  group Tests
    ./tests/: Tests.cpp Tests.h TestValuesFPGA.cpp TestValueSTRICT.cpp Utils.cpp
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC536)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: Panel +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PANEL
  c misc: --cpp --diag_suppress=4487
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\Panel.sct
